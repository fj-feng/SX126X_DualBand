# Keil uVision project 1262node.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 1262node
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ..\Core\Inc;..\Drivers\STM32L0xx_HAL_Driver\Inc;..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\Drivers\CMSIS\Include;..\HARDWARE\SX126X;..\HARDWARE\Board\EXTI;..\HARDWARE\Board\RCC;..\HARDWARE\Board\SPI;..\HARDWARE\Board\TIMER;..\HARDWARE\Board\UART;..\LoRa-126x_Driver;..\HARDWARE\Board\Log;..\HARDWARE\Board\GPIO;..\HARDWARE\Board\DMA;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x15000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Hardware
    ../HARDWARE/Board/UART/: uart.c
    ../HARDWARE/Board/TIMER/: timer.c
    ../HARDWARE/Board/RCC/: rcc.c
    ../HARDWARE/Board/Log/: log.c
    ../HARDWARE/Board/GPIO/: gpio.c
    ../HARDWARE/Board/DMA/: dma.c
    ../HARDWARE/Board/SPI/: spi.c
  group Application/User/Core
    ../Core/Src/: stm32l0xx_hal_msp.c stm32l0xx_it.c main.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group LoRa-126x_Driver
    ../LoRa-126x_Driver/: LoRa126x_Driver.c LoRa126x_Hal.c LoRa126x_Fun.c LoRa126x_it.c
  group App
    ../App/: TestFun.c uartString.c
